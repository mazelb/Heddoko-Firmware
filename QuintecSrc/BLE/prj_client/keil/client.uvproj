# Keil uVision project client.uvproj, settings and files
target client (ARM-ADS)
  device: QN9020 Quintic
  cpu: IRAM(0x00008000-0x0000FFFF) IROM(0x00000000-0x00007FFF) CLOCK(16000000) CPUTYPE("Cortex-M0")
  output: client
  AfterMake: fromelf --bin --output ./bin/client.bin ./obj/client.axf
  c flags: Optim=1 OneElfS=1
  c misc: --C99
  c include: ..\src;..\..\src\app;..\..\src\app\basc;..\..\src\app\blpc;..\..\src\app\disc;..\..\src\app\findl;..\..\src\app\gap;..\..\src\app\gatt;..\..\src\app\glpc;..\..\src\app\hrpc;..\..\src\app\htpc;..\..\src\app\proxm;..\..\src\app\scppc;..\..\src\app\smp;..\..\src\app\tipc;..\..\src\cmsis;..\..\src\driver;..\..\src\fw;..\..\src\lib;..\..\src\profiles;..\..\src\profiles\bas\basc;..\..\src\profiles\blp;..\..\src\profiles\blp\blpc;..\..\src\profiles\blp\blps;..\..\src\profiles\dis\disc;..\..\src\profiles\find\findl;..\..\src\profiles\glp;..\..\src\profiles\glp\glpc;..\..\src\profiles\glp\glps;..\..\src\profiles\hrp;..\..\src\profiles\hrp\hrpc;..\..\src\profiles\htp;..\..\src\profiles\htp\htpc;..\..\src\profiles\prox\proxm;..\..\src\profiles\scpp;..\..\src\profiles\scpp\scppc;..\..\src\profiles\tip;..\..\src\profiles\tip\tipc;..\..\src\qnevb;..\..\src\app\anpc;..\..\src\app\cscpc;..\..\src\app\paspc;..\..\src\app\rscpc;..\..\src\profiles\anp;..\..\src\profiles\anp\anpc;..\..\src\profiles\cscp;..\..\src\profiles\cscp\cscpc;..\..\src\profiles\pasp;..\..\src\profiles\pasp\paspc;..\..\src\profiles\rscp;..\..\src\profiles\rscp\rscpc;..\..\src\profiles\hogp;..\..\src\profiles\hogp\hogpbh;..\..\src\profiles\hogp\hogprh;..\..\src\app\hogpbh;..\..\src\app\hogprh;..\..\src\app\qppc;..\..\src\app\qpps;..\..\src\profiles\qpp;..\..\src\profiles\qpp\qppc;..\..\src\profiles\qpp\qpps
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x8000 size 0x8000
  scatter file: ..\..\src\link\keil\qn9020_link.sct
  link misc: --no_autoat
  group startup
    ../../src/startup/keil/: startup.s
  group main
    ../../src/main/: app_main.c
  group usr
    ../src/: system.c usr_design.c diskio.c pff.c
  group app
    ../../src/app/: app_env.c app_menu.c app_printf.c app_sys.c app_task.c app_util.c
    ../../src/app/gap/: app_gap.c app_gap_task.c
    ../../src/app/gatt/: app_gatt.c app_gatt_task.c
    ../../src/app/smp/: app_smp.c app_smp_task.c
    ../../src/app/disc/: app_disc.c app_disc_task.c
    ./: app_qppc.c app_qppc_task.c app_qpps.c app_qpps_task.c
  group profiles
    ../../src/profiles/: prf_utils.c
    ../../src/profiles/dis/disc/: disc.c disc_task.c
  group drivers
    ../../src/driver/: uart.c gpio.c sleep.c syscon.c timer.c rtc.c dma.c
    ./: spi.c
  group lib
    ../../src/lib/keil/: qn9020b2_lib_allroles.lib
    ../../src/profiles/qpp/qppc/: qn_qppc.lib
  group qnevb
    ../../src/qnevb/: led.c
  group retarget
    ../../src/retarget/: retarget.c
